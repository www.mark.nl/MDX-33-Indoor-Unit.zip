Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2024-04-22T13:21:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.2.1.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 22 13:21:47 2024 * Host: MBACIU-RO-LE * Database: C:\Users\Mbaciu\AppData\Local\Temp\de1aef84-afb8-4a34-8f42-db908ac27beb\398c3ac1-e6d5-40f4-91f9-f32e2ada4e40\ifc * Database version: 5507 * Database creation date: Mon Apr 22 13:21:45 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Apr 22 13:21:46 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 22 13:21:46 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcAirTerminal: VE_Air Heater_MEPcontent_Mark_Mistral MDX 33_INT-EN:MDX 33 Indoor Unit, VE_Air Heater_MEPcontent_Mark_Mistral MDX 33_INT-EN:MDX 33 Indoor Unit:1323838
In: F00
Type - Material: Color RGB 060-060-060, Color RGB 193-193-194, Color RGB 000-000-255
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 879 mm; Drain Diameter: 40 mm; Height: 940 mm; Refrigerant Gas Diameter: 28 mm; Refrigerant Liquid Diameter: 12.7 mm; Width: 1170 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 24 W
Type - Identity Data - Article Description: Air-to-air VRF heat pump system; Article Type: MDX 33 Indoor Unit; Base Family Version: 24.06; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Air-to-air VRF heat pump system; EMCS Version: 5.0; ETIM Article Class: EC011395; Family Version: 24.05; Manufacturer: Mark; Manufacturer Art. No.: 5060705; Manufacturer URL: https://www.markclimate.com/products/heat-pumps/mistral-mdx-vrf-heat-pump-system/; MEPcontent Class: AIR_HEATER; Model: MDX 33 Indoor Unit; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Mark; Revit Version: 2021; Type Name: MDX 33 Indoor Unit; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Loads - Airflow Rate (m3/h): 6600; Sound Pressure Level (dB(A)): 53; Unit Weight (kg): 112
Type - Other - Category: Mechanical Equipment; A: 404 mm; Depth Safe: 733 mm; Family Name: VE_Air Heater_MEPcontent_Mark_Mistral MDX 33_INT-EN
Type - Pset_ManufacturerTypeInformation - Manufacturer: Mark
Pset_AirTerminalBoxTypeCommon - Reference: MDX 33 Indoor Unit; sets with these values: 3
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 13.6257 m2; Volume: 0.835662 m3
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Undefined,Sanitary,Power
Other - Back Clearance Safe: 600 mm; Bottom Clearance Safe: 180 mm; F: 1240 mm; Family: VE_Air Heater_MEPcontent_Mark_Mistral MDX 33_INT-EN: MDX 33 Indoor Unit; Family and Type: VE_Air Heater_MEPcontent_Mark_Mistral MDX 33_INT-EN: MDX 33 Indoor Unit; Left Clearance Safe: 1000 mm; R: 732 mm; Right Clearance Safe: 1000 mm; S: 470 mm; Top Clearance Safe: 50 mm; Type: VE_Air Heater_MEPcontent_Mark_Mistral MDX 33_INT-EN: MDX 33 Indoor Unit; Type Id: VE_Air Heater_MEPcontent_Mark_Mistral MDX 33_INT-EN: MDX 33 Indoor Unit; Vertical Offset: 0 mm
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Back Clearance: 600 mm; Bottom Clearance: 180 mm; Bracket Floor: yes; Bracket Suspended: no; Condensate Drain without Pump: yes; Left Clearance: 1000 mm; Right Clearance: 1000 mm; Show Service Space: no; Top Clearance: 50 mm

# IfcBuildingElementProxy: M_Bracket Floor MDX 33_Geometry:Bracket Floor, M_Bracket Floor MDX 33_Geometry:Bracket Floor:1323839
In: F00
Type - Material: Color RGB 193-193-194
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Article Description: Bracket Floor; Article Type: Bracket Floor; Manufacturer: Mark; Manufacturer Art. No.: 5016840; Manufacturer URL: https://www.markclimate.com/products/heat-pumps/mistral-mdx-vrf-heat-pump-system/; OmniClass Number: 23.60.30.11.17; OmniClass Title: Pipework/Ductwork Mechanical Fasteners/Supports; Product Line: Mark; Type Name: Bracket Floor
Type - Materials and Finishes - Grey: Color RGB 193-193-194
Type - Other - Category: Mechanical Equipment; Family Name: M_Bracket Floor MDX 33_Geometry
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Mark
Pset_BuildingElementProxyCommon - Reference: Bracket Floor
Pset_EnvironmentalImpactIndicators - Reference: Bracket Floor
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 0.386134 m2; Volume: 0.00526742 m3
Identity Data - Mark: 5
Other - Family: M_Bracket Floor MDX 33_Geometry: Bracket Floor; Family and Type: M_Bracket Floor MDX 33_Geometry: Bracket Floor; Floor Bracket: yes; Type: M_Bracket Floor MDX 33_Geometry: Bracket Floor; Type Id: M_Bracket Floor MDX 33_Geometry: Bracket Floor
Phasing - Phase Created: 4. Plan over 10 years

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection
2 x Port_1323838 | SOURCE
Port_1323838 | SOURCEANDSINK
Port_1323838 | SINK
